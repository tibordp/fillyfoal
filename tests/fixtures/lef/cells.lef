VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
LAYER metal1
  TYPE ROUTING ;
  DIRECTION HORIZONTAL ;
  PITCH 0.2 ;
END metal1
SITE core
  CLASS CORE ;
  SIZE 0.2 BY 2.0 ;
END core
MACRO INVX1
  CLASS CORE ;
  SIZE 0.6 BY 2.0 ;
  PIN A
    DIRECTION INPUT ;
  END A
END INVX1
END LIBRARY
